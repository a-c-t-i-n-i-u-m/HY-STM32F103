# Keil uVision project STM32-FD-AT45DB161D-SPI.uvproj, settings and files
target STM32-SPI-AT45DB161D (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FD_AD45DB161D-SPI +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c
    ./user/: stm32f10x_it.c SPI_Flash.c
  group StdPeriph_Driver
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group RVMDK
    ./startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./user/: system_stm32f10x.c core_cm3.c
