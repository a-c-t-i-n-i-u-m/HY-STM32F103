# Keil uVision project STm32-FD-Touch.uvproj, settings and files
target STM32-FD-TOUCH (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-fd-touch +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user;.\CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: fsmc_sram.c lcd_dis24.c touch.c stm32f10x_it.c SPI_Flash.c
    ./FWlib/SRC/: stm32f10x_spi.c
  group FWlib
    ./FWlib/SRC/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
