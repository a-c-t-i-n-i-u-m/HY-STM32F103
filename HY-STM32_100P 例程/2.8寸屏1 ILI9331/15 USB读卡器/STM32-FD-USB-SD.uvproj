# Keil uVision project STM32-FD-USB-SD.uvproj, settings and files
target STM32-FD-USB-SD (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-USB-SD +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\usb_library\inc;..\USB_test;.\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start_up
    ./startup/: startup_stm32f10x_hd.s
  group Source
    ./user/: hw_config.c main.c usb_istr.c usb_prop.c usb_pwr.c sdcard.c
  group Interrupt
    ./user/: stm32f10x_it.c
  group Library
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_sdio.c stm32f10x_dma.c
  group USBLib
    ./usb_library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c memory.c usb_bot.c usb_scsi.c scsi_data.c usb_desc.c usb_endp.c
  group Document
    ./: readme.txt
  group CMSYS
    ./user/: core_cm3.c system_stm32f10x.c
