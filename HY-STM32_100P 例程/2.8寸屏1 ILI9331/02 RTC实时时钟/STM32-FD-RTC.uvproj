# Keil uVision project STM32-FD-RTC.uvproj, settings and files
target STM32-FD-RTC (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: release0 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\user;.\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./user/: main.c
  group Startup Code
    ./startup/: startup_stm32f10x_hd.s
  group Interrupts
    ./user/: stm32f10x_it.c
  group Library
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_pwr.c
  group Documentation
    ./: readme.txt
