# Keil uVision project STM32-FD-uCOSII2.86DEMO.uvproj, settings and files
target STM32-FD-uCos286DEMO (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-286Demo +hex
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\..\STM32奋斗板-uCOSII2.86DEMO;..\FWlib\inc;..\APP;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ./: app.c vectors.s
  group BSP
    ../BSP/: bsp.c init.s bsp_int.c
  group FWLib
    ../FWlib/SRC/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c misc.c
  group uC-CPU
    ../uC-CPU/ARM-Cortex-M3/: cpu_a.asm cpu_c.c
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-LIB
    ../uC-LIB/: lib_mem.c lib_str.c
    ../uC-LIB/Ports/: lib_mem_a.asm
  group usart
    ./: Usart.c
  group Doc
    ./: readme.txt
