# Keil uVision project STM32-FD-SDCard-SDIO.uvproj, settings and files
target STM32-SDCard-SDIO (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FD_SDCard-SDIO +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\user;.\fatfs;.\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: stm32f10x_it.c sdcard.c main.c
  group StdPeriph_Driver
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c
  group RVMDK
    ./startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./user/: system_stm32f10x.c core_cm3.c
  group FATFS
    ./fatfs/: ff.c diskio.c
