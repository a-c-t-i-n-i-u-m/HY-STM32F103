# Keil uVision project STM32-FD-ucgui.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-ucgui +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\uCGUIConfig;..\uCGUI\emWinDemo;..\GUIinc;..\TFT;..\uCGUI\uCGUIDemo
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: cortexm3_macro.s stm32f10x_startup.s
  group APP
    ./: app.c stm32f10x_it.c
  group BSP
    ../BSP/: bsp.c
  group FWLib
    ../FWlib/SRC/: misc.c system_stm32f10x.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./: core_cm3.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCGUILib
    ../uCGUILib/: uCGUI_DEMO.lib
  group usart
    ../usart/: Com.c SPI_Flash.c
  group Documentation
    ./: readme.txt
  group uCOS-II/GUI_X
    ../uCOS-IIGUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
  group TFT
    ../TFT/: ili9320_api.c ili9320_ucgui.c ili9320.c
    ./: lcd_dis24.c pic.c fsmc_sram.c
  group GUIDEMO
    ../uCGUIDemo/: MicriumLogoWRed.c GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Bitmap.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_WM.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c MicriumLogo.c
  group font
    ../font/: hwhb_32.c STCaiYun_35.c
target RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: "VECT_TAB_RAM"
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
