# Keil uVision project STM32-FD-ADC.uvproj, settings and files
target STM32-FD-ADC (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-ADC +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./startup/: startup_stm32f10x_hd.s
  group Source Code
    ./user/: main.c stm32f10x_it.c
  group libary
    ./FWlib/SRC/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c
  group Document
    ./: readme.txt
